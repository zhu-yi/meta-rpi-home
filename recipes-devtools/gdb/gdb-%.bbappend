EXTRA_OECONF_append = "--enable-tui"
