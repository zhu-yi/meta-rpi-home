FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

JIVE_USE_CJK_FONT = "1"
